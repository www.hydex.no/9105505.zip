# Autodesk Inventor part: DVLF40_20_body
## iProperties
Created: 2009-11
Part Number: DVLF40_20_body
Document SubType Name: Modeling
Designer: TB
Mass: 335.405 g
Surface Area: 786.057 cm^2
Volume: 335.405 cm^3
Density: 1 g/cm^3
Author: TB
## Feature names
1. Kropp [Revolution]
2. Chamfer
3. Extrusion2
4. Hole1
5. Revolution2
6. Hole2
7. Fillet1
8. Extrusion3
9. Hole3
